<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" historyDataVersion="7" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Oct 25 22:19:59 2026</timestamp>
			<uuid>{1e8485c4-b373-41a5-bdc2-c91b67b9b45c}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/nethome/lgelin3/ECE6130_Updated/ECE6130_LAB/Cadence/ECE6130-SRAMVirtuosoGroup15/SRAM_Group15_Lib/sram_tb_sweep/maestro_sweep/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/nethome/lgelin3/simulation/SRAM_Group15_Lib/sram_tb_sweep/maestro_sweep/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/SRAM_Group15_Lib/sram_tb_sweep/maestro_sweep/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
